# Keil uVision project test.uvprojx, settings and files
target Targets1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CHECK;..\HARDWARE\Remote;..\HARDWARE\InfraRed;..\HARDWARE\Key;..\HARDWARE\Led;..\HARDWARE\NixieTube;..\HARDWARE\Ultrasonic;..\INTERRUPT\ChangeMode;..\TIME\Pwm;..\HARDWARE\Buzzer;..\HARDWARE\Copycat;..\HARDWARE\BlueTooth
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USR
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart2.c
  group INTERRUPT
    ../INTERRUPT/ChangeMode/: changemode.c changemode.h
  group TIME
    ../TIME/Pwm/: pwm.c pwm.h
  group CHECK
    ../CHECK/: check.c check.h
  group HARDWARE
    ../HARDWARE/InfraRed/: infrared.c infrared.h
    ../HARDWARE/Key/: key.c key.h
    ../HARDWARE/Led/: led.c led.h
    ../HARDWARE/NixieTube/: nixietube.c nixietube.h
    ../HARDWARE/Ultrasonic/: ultrasonic.c ultrasonic.h
    ../HARDWARE/Buzzer/: buzzer.c buzzer.h
    ../HARDWARE/Copycat/: copycat.c copycat.h
    ../HARDWARE/Remote/: remote.c remote.h
    ../HARDWARE/BlueTooth/: bluetooth.c bluetooth.h
software components: CMSIS:CORE 5.1.1
