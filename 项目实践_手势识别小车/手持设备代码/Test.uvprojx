# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: .\inc;.\inc\sys;.\inc\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USR
    ./src/: main.c startup_stm32f10x_hd.s
  group HARDWARE
    ./src/: led.c hc05.c usart2.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
  group inc
    ./inc/: led.h hc05.h usart2.h mpu6050.h mpuiic.h
  group sys
    ./src/: usart.c sys.c delay.c
